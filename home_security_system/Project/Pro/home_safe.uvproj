# Keil uVision project home_safe.uvproj, settings and files
target home_safe (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: home_safe +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS\CoreSupport;..\..\CMSIS\STM32F10x;..\..\Hardware\inc;..\..\Hardware\SIM900A;..\..\Libraries\inc;..\..\system\inc;..\..\user\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../../user/src/: main.c stm32f10x_it.c
  group hardware
    ../../Hardware/src/: ADC.c dht11.c fire.c key.c led.c red.c smoke.c usart2.c motor.c beep.c figure.c usart3.c exti.c
    ../../Hardware/SIM900A/: sim900a.c
  group system
    ../../system/src/: delay.c sys.c usart.c
  group CMSIS
    ../../CMSIS/CoreSupport/: core_cm3.c
    ../../CMSIS/STM32F10x/: system_stm32f10x.c
  group startup
    ../../startup/arm/: startup_stm32f10x_hd.s
  group libraries
    ../../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c
  group description
    ../../Description/: Description.txt
